# Repository ramunecyudokusha/Ariake2026offseasonKairo (continued)

## KiCad design md_test_v1/moterdriver_test_v1.kicad_pcb (continued)

Board: 2 copper layers, 70.5 x 45.0 mm, 36 parts (17 on the bottom side), 27 nets.

File md_test_v1/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2, C5",0603,3,1uF,
"C10, C3, C9",0805,3,10uF,
"C4, C6, C7",0603,3,0.1uf,
C8,CP_Radial_D12.5mm_P5.00mm,1,250uF,
D2,D_SMB,1,SMBJ26A,
D3,D_SOD-123,1,D_Zener,
J1,AMASS_XT30PW-M_1x02_P2.50mm_Horizontal,1,Conn_01x02_Socket,
J3,AMASS_XT30PW-F_1x02_P2.50mm_Horizontal,1,Conn_01x02_Socket,
J4,PinHeader_2x06_P2.54mm_Vertical,1,Conn_02x06_Odd_Even,
"Q1, Q2, Q3, Q4, Q5, Q6",TO-252-2,6,Q_NMOS_GDS,
"R10, R11, R13, R4, R6, R7, R8, R9",0603,8,10k,
R12,0603,1,1k,
"R14, R15",0603,2,10,
R2,0603,1,18k,
R3,0603,1,200k,
R5,1225,1,2m,
U1,RGE0024F,1,DRV8701PRGER,

## KiCad design solenoid_control/only_solenoid/sorenoids_10.kicad_pcb

Board: 2 copper layers, 75.0 x 90.0 mm, 63 parts (0 on the bottom side), 43 nets.

Parts:
D2, D9, D10, D11, D12, D13, D14, D15: D; D_SOD-323F
H2, H3, H4, H5: MountingHole; MountingHole_3.2mm_M3
J1, J3: Conn_01x05_Pin; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
J2, J9, J10, J11, J12, J13, J14, J15: Conn_01x02_Socket; JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal
J4: Conn_01x02_Pin; AMASS_XT30U-F_1x02_P5.0mm_Vertical
Q1, Q3, Q4, Q5, Q6, Q7, Q8, Q16: Q_NMOS_Depletion_GDS; TO-252-2
R4, R25, R28, R31, R34, R37, R40, R43: 330; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
R5, R6, R26, R27, R29, R30, R32, R33, R35, R36, R38, R39, R41, R42, R44, R45: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P1.90mm_Vertical
U2, U9, U10, U11, U12, U13, U14, U15: TLP785; DIP-4_W7.62mm

Connections:
+24V: D2.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), J2.1, J4.2, J9.1, J10.1, J11.1, J12.1, J13.1, J14.1, J15.1, U2.4, U9.4, U10.4, U11.4, U12.4, U13.4, U14.4, U15.4
/sore1/Signal: J1.1, R25.2
/sore2/Signal: J1.2, R4.2
/sore3/Signal: J1.3, R28.2
/sore4/Signal: J1.4, R31.2
/sore5/Signal: J3.1, R34.2
/sore6/Signal: J3.2, R37.2
/sore7/Signal: J3.3, R40.2
/sore8/Signal: J3.4, R43.2
GND: J1.5, J3.5, U2.2, U9.2, U10.2, U11.2, U12.2, U13.2, U14.2, U15.2
GND1: J4.1, Q1.3 (S), Q3.3 (S), Q4.3 (S), Q5.3 (S), Q6.3 (S), Q7.3 (S), Q8.3 (S), Q16.3 (S), R6.2, R27.2, R30.2, R33.2, R36.2, R39.2, R42.2, R45.2
unnamed: D2.2 (A), J2.2, Q3.2 (D)
unnamed: D9.2 (A), J9.2, Q1.2 (D)
unnamed: D10.2 (A), J10.2, Q4.2 (D)
unnamed: D11.2 (A), J11.2, Q5.2 (D)
unnamed: D12.2 (A), J12.2, Q6.2 (D)
unnamed: D13.2 (A), J13.2, Q7.2 (D)
unnamed: D14.2 (A), J14.2, Q8.2 (D)
unnamed: D15.2 (A), J15.2, Q16.2 (D)
unnamed: Q1.1 (G), R26.2, R27.1
unnamed: Q3.1 (G), R5.2, R6.1
unnamed: Q4.1 (G), R29.2, R30.1
unnamed: Q5.1 (G), R32.2, R33.1
unnamed: Q6.1 (G), R35.2, R36.1
unnamed: Q7.1 (G), R38.2, R39.1
unnamed: Q8.1 (G), R41.2, R42.1
unnamed: Q16.1 (G), R44.2, R45.1
unnamed: R4.1, U2.1
unnamed: R5.1, U2.3
unnamed: R25.1, U9.1
unnamed: R26.1, U9.3
unnamed: R28.1, U10.1
unnamed: R29.1, U10.3
unnamed: R31.1, U11.1
unnamed: R32.1, U11.3
unnamed: R34.1, U12.1
unnamed: R35.1, U12.3
unnamed: R37.1, U13.1
unnamed: R38.1, U13.3
unnamed: R40.1, U14.1
unnamed: R41.1, U14.3
unnamed: R43.1, U15.1
unnamed: R44.1, U15.3

## KiCad design powerboard_ver2/powerboard_v2.kicad_pcb

Parts:
C13, C14: C_Polarized 1000uf; CP_Radial_D12.5mm_P5.00mm
D1: D; D_SMA
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x02_Pin; AMASS_XT60PW-F_1x02_P7.20mm_Horizontal
J2, J3, J6, J7: Conn_01x02_Pin; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
J4: Conn_01x02_Pin; JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal
J5: Conn_01x02_Pin; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
JP1: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
K3: Relay_SPDT; Relay_SPDT_RAYEX-L90S
R1: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2: 100; R_Axial_DIN0516_L15.5mm_D5.0mm_P5.08mm_Vertical
R3: 70; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U5: TLP785; DIP-4_W7.62mm

Connections:
+3.3V: J4.1, R3.1
+7.5V: C14.1, J2.2, J3.2, J6.2, J7.2, JP1.2 (B)
+24V: D1.1 (K), J5.2, K3.14, K3.A1
GND: C13.2, C14.2, J1.1, J2.1, J3.1, J5.1, J6.1, J7.1, R2.1, U5.3
GND1: J4.2, R1.1, U5.2
unnamed: R1.2, R3.2, U5.1
cap out: K3.12, R2.2
photo in: D1.2 (A), K3.A2, U5.4
xt60_out: C13.1, J1.2, JP1.1 (A), K3.11

Board: 2 copper layers, 72.0 x 68.0 mm, 20 parts (1 on the bottom side), 9 nets.

## KiCad design moter_powerup_boardv1/moter_upgrade_boardv1.kicad_pcb

Parts:
C1: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2: 4.7uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C5: 0.1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4: 1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: LED_YELLOW; D_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2: LED_Green; D_0805_2012Metric_Pad1.15x1.40mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x05_Socket; JST_XH_S5B-XH-A-1_1x05_P2.50mm_Horizontal
J2: Conn_ST_STDC14; PinHeader_2x07_P1.27mm_Vertical
J3, J4, J5: Conn_01x02_Socket; JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal
J6: Conn_01x03_Pin; TerminalBlock_RND_205-00233_1x03_P5.08mm_Horizontal
R1: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R3: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R5, R6, R7, R8: 10k; R_0805_2012Metric
SW1: SW_Wuerth_450301014042; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm
SW2, SW3, SW4: SW_Push; SW_PUSH_6mm
U1: TCAN3414DRBR; XCVR_TCAN3414DRBR; PARTREV A
U2: STM32C092CBT6; LQFP48_STM

Connections:
+3.3V: C1.2, C2.2, C3.1, C4.1, J1.2, J2.3 (VCC), J5.2, R5.1, R6.1, R7.1, R8.1, U1.3 (VCC), U2.5 (VREF+), U2.6 (VDD/VDDA)
/ma: R7.2, SW2.1, U2.26 (PB14)
/mb: R5.2, SW3.1, U2.25 (PB13)
CAN1R: R1.2, SW1.2 (C)
CAN1_+: J3.1, J4.2, R1.1, U1.7 (CANH)
CAN1_-: J3.2, J4.1, SW1.1 (B), U1.6 (CANL)
CAN1rx: U1.4 (RXD), U2.19 (PB0)
CAN1tx: U1.1 (TXD), U2.20 (PB1)
GND: C1.1, C2.1, C3.2, C4.2, C5.2, J1.5, J2.5 (GND), J2.7 (GND), J2.11 (GNDDetect), J5.1, J6.3, R2.1, R3.1, R4.2, SW2.2, SW3.2, SW4.2, U1.2 (GND), U1.5 (SHDN), U1.8 (STB), U1.9 (EXP), U2.7 (VSS/VSSA)
unnamed: D1.2 (A), U2.24 (PB12)
unnamed: D1.1 (K), R2.2
unnamed: D2.2 (A), U2.23 (PB11)
unnamed: D2.1 (K), R3.2
dir to moter: J6.1, U2.13 (PA2)
en-a: J1.3, U2.46 (PB7)
en-b: J1.1, U2.45 (PB6)
en-x: J1.4
nrst: C5.1, J2.12 (~RST), R6.2, SW4.1, U2.10 (PF2-NRST)
pwm to moter: J6.2, U2.11 (PA0)
strx: J2.13 (VCP_RX), U2.28 (PA8)
sttx: J2.14 (VCP_TX), U2.29 (PA9)
swclk: J2.6 (JCLK/SWCLK), R4.1, U2.36 (PA14-BOOT0)
swdio: J2.4 (JTMS/SWDIO), R8.2, U2.35 (PA13)

Notes on the sheet:
リセット用スイッチ
エンコーダ用

Board: 2 copper layers, 52.0 x 50.0 mm, 31 parts (13 on the bottom side), 22 nets.

## Code that names these connections

File solenoid_control/solenoid_withSTM/solenoid_control/solenoid_control.ioc (part):

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Mcu.Name=STM32H533CETx
Mcu.Package=LQFP48
Mcu.UserName=STM32H533CETx
PA0.Signal=S_TIM2_CH1
PA1.Signal=S_TIM2_CH2
PA11.Mode=FDCAN_Activate
PA11.Signal=FDCAN1_RX
PA12.Mode=FDCAN_Activate
PA12.Signal=FDCAN1_TX
PA13(JTMS/SWDIO).Mode=JTAG_5_pins
PA13(JTMS/SWDIO).Signal=DEBUG_JTMS-SWDIO
PA14(JTCK/SWCLK).Mode=JTAG_5_pins
PA14(JTCK/SWCLK).Signal=DEBUG_JTCK-SWCLK
PA15(JTDI).Mode=JTAG_5_pins
PA15(JTDI).Signal=DEBUG_JTDI
PA2.Signal=S_TIM2_CH3
PA3.Signal=S_TIM2_CH4
PA6.Signal=S_TIM3_CH1
PA7.Signal=S_TIM3_CH2
PB0.Signal=S_TIM3_CH3
PB1.Signal=S_TIM3_CH4
PB12.Signal=GPIO_Analog
PB13.Signal=GPIO_Analog
PB14.Signal=GPIO_Analog
PB15.Signal=GPIO_Analog
PB3(JTDO/TRACESWO).Mode=JTAG_5_pins
PB3(JTDO/TRACESWO).Signal=DEBUG_JTDO-SWO
PB4(NJTRST).Mode=JTAG_5_pins
PB4(NJTRST).Signal=DEBUG_NJTRST
PC14-OSC32_IN(OSC32_IN).Signal=GPIO_Input
PC15-OSC32_OUT(OSC32_OUT).Signal=GPIO_Output
PH0-OSC_IN(PH0).Signal=GPIO_Input
PH1-OSC_OUT(PH1).Signal=GPIO_Output
RCC.HSE_VALUE=25000000
RCC.SYSCLKFreq_VALUE=32000000
board=custom

File LED_board_v1/program/tape_led_board/tape_led_board.ioc (part):

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Mcu.Name=STM32H533CETx
Mcu.Package=LQFP48
Mcu.UserName=STM32H533CETx
PA0.Signal=S_TIM2_CH1
PA1.Signal=S_TIM2_CH2
PA11.Mode=FDCAN_Activate
PA11.Signal=FDCAN1_RX
PA12.Mode=FDCAN_Activate
PA12.Signal=FDCAN1_TX
PA13(JTMS/SWDIO).Mode=JTAG_5_pins
PA13(JTMS/SWDIO).Signal=DEBUG_JTMS-SWDIO
PA14(JTCK/SWCLK).Mode=JTAG_5_pins
PA14(JTCK/SWCLK).Signal=DEBUG_JTCK-SWCLK
PA15(JTDI).Mode=JTAG_5_pins
PA15(JTDI).Signal=DEBUG_JTDI
PA2.Signal=S_TIM2_CH3
PA3.Signal=S_TIM2_CH4
PA6.Signal=S_TIM3_CH1
PA7.Signal=S_TIM3_CH2
PB0.Signal=S_TIM3_CH3
PB1.Signal=S_TIM3_CH4
PB3(JTDO/TRACESWO).Mode=JTAG_5_pins
PB3(JTDO/TRACESWO).Signal=DEBUG_JTDO-SWO
PB4(NJTRST).Mode=JTAG_5_pins
PB4(NJTRST).Signal=DEBUG_NJTRST
PB5.Mode=Multiprocessor_communication
PB5.Signal=UART5_RX
PB6.Mode=Multiprocessor_communication
PB6.Signal=UART5_TX
PC14-OSC32_IN(OSC32_IN).Signal=GPIO_Input
PC15-OSC32_OUT(OSC32_OUT).Signal=GPIO_Output
PH0-OSC_IN(PH0).Signal=GPIO_Input
PH1-OSC_OUT(PH1).Signal=GPIO_Output
RCC.HSE_VALUE=25000000
RCC.SYSCLKFreq_VALUE=32000000
board=custom

File moter_powerup_boardv3/MDPID_V3/MDPID_V3.ioc (part):

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Mcu.Name=STM32H533CETx
Mcu.Package=LQFP48
Mcu.UserName=STM32H533CETx
PA0.Signal=S_TIM2_CH1
PA1.Signal=S_TIM2_CH2
PA11.Mode=FDCAN_Activate
PA11.Signal=FDCAN1_RX
PA12.Mode=FDCAN_Activate
PA12.Signal=FDCAN1_TX
PA13(JTMS/SWDIO).Mode=JTAG_5_pins
PA13(JTMS/SWDIO).Signal=DEBUG_JTMS-SWDIO
PA14(JTCK/SWCLK).Mode=JTAG_5_pins
PA14(JTCK/SWCLK).Signal=DEBUG_JTCK-SWCLK
PA15(JTDI).Mode=JTAG_5_pins
PA15(JTDI).Signal=DEBUG_JTDI
PA4.Signal=GPIO_Analog
PA6.Signal=GPIO_Analog
PA8.Signal=S_TIM1_CH1
PA9.Signal=S_TIM1_CH2
PB0.Signal=GPIO_Analog
PB3(JTDO/TRACESWO).Mode=JTAG_5_pins
PB3(JTDO/TRACESWO).Signal=DEBUG_JTDO-SWO
PB4(NJTRST).Mode=JTAG_5_pins
PB4(NJTRST).Signal=DEBUG_NJTRST
PB5.Signal=UART5_RX
PB6.Signal=UART5_TX
PC14-OSC32_IN(OSC32_IN).Signal=GPIO_Input
PC15-OSC32_OUT(OSC32_OUT).Signal=GPIO_Output
PH0-OSC_IN(PH0).Signal=GPIO_Input
PH1-OSC_OUT(PH1).Signal=GPIO_Output
RCC.HSE_VALUE=25000000
RCC.SYSCLKFreq_VALUE=32000000
board=custom
