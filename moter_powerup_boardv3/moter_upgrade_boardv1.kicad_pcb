# Repository ramunecyudokusha/Ariake2026offseasonKairo

File README.md:

# Ariake2026offseasonKairo
有明高専ロボット研究部2026オフシーズン回路開発

## KiCad design moter_powerup_boardv3/moter_upgrade_boardv1.kicad_pcb

Parts:
C1, C11, C14: 4.7uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C6, C7, C8, C9, C10, C13: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3: 0.1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4, C5: 2.2uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C12: 10nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C15: 220uF; CP_Elec_6.3x4.5
D1: LED_YELLOW; D_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2: LED_Green; D_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D3, D4: D_Shockley; D_SMB
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x05_Socket; JST_XH_S5B-XH-A-1_1x05_P2.50mm_Horizontal
J2: Conn_ST_STDC14; PinHeader_2x07_P1.27mm_Vertical
J3, J5: Conn_01x03_Pin; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
J4: Conn_01x05_Socket; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
J6: Conn_01x03_Pin; JST_XH_S3B-XH-A-1_1x03_P2.50mm_Horizontal
J7: Conn_01x02_Socket; JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal
L1: 22uH; L_6.3x6.3_H3
R1: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 10k; R_0805_2012Metric
R4, R5: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7: 5.90k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_Wuerth_450301014042; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm
SW2: SW_Push; SW_PUSH_6mm
U2: STM32H533CETx; LQFP-48_7x7mm_P0.5mm
U3: TPS5430DDA; TI_SO-PowerPAD-8_ThermalVias
U4: PTCAN3413DR; SOIC8_D_TEX

Connections:
+3.3V: C1.1, C2.1, C6.1, C7.1, C8.1, C9.1, C10.1, C13.2, C15.1, J1.2, J2.3 (VCC), L1.2, R3.1, R6.1, U2.1 (VBAT), U2.9 (VDDA), U2.24 (VDD), U2.36 (VDD), U2.48 (VDD), U4.3 (VCC), U4.5 (SHDN,VIO)
+24V: C11.1, C14.1, D4.1 (K), U3.7 (VIN)
/ma: U2.5 (PH0)
CAN1R: R1.2, SW1.1 (B)
CAN1_+: J3.2, J5.2, SW1.2 (C), U4.7 (CANH)
CAN1_-: J3.3, J5.1, R1.1, U4.6 (CANL)
CAN1rx: U2.32 (PA11), U4.4 (RXD)
CAN1tx: U2.33 (PA12), U4.1 (TXD)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C13.1, C14.2, C15.2, D3.2 (A), J1.5, J2.5 (GND), J2.7 (GND), J2.11 (GNDDetect), J3.1, J4.5, J5.3, J6.1, J7.1, R4.1, R5.1, R7.2, SW2.2, U2.8 (VSSA), U2.23 (VSS), U2.35 (VSS), U2.47 (VSS), U3.6 (GND), U3.9 (GNDPAD), U4.2 (GND), U4.8 (STB)
JTDI: J2.10 (JTDI/NC), U2.38 (PA15(JTDI))
JTDO-SWO: J2.8 (JTDO/SWO), U2.39 (PB3(JTDO)
NJTRST: U2.40 (PB4(NJTRST))
unnamed: C4.1, U2.22 (VCAP)
unnamed: C5.1, U2.46 (VCAP)
unnamed: D1.2 (A), U2.3 (PC14)
unnamed: D1.1 (K), R4.2
unnamed: D2.2 (A), U2.4 (PC15)
unnamed: D2.1 (K), R5.2
unnamed: C12.2, D3.1 (K), L1.1, U3.8 (PH)
unnamed: D4.2 (A), J7.2
unnamed: J4.1, U2.25 (PB12)
unnamed: J4.2, U2.26 (PB13)
unnamed: J4.3, U2.27 (PB14)
unnamed: J4.4, U2.28 (PB15)
unnamed: C12.1, U3.1 (BOOT)
unnamed: R6.2, R7.1, U3.4 (VSENSE)
PWM1: J6.2, U2.29 (PA8)
PWM2: J6.3, U2.30 (PA9)
en-a: J1.1, U2.10 (PA0)
en-b: J1.3, U2.11 (PA1)
en-x: J1.4
nrst: C3.1, J2.12 (~RST), R3.2, SW2.1, U2.7 (NRST)
strx: J2.13 (VCP_RX), U2.42 (PB6)
sttx: J2.14 (VCP_TX), U2.41 (PB5)
swclk: J2.6 (JCLK/SWCLK), U2.37 (PA14(JTCK)
swdio: J2.4 (JTMS/SWDIO), U2.34 (PA13(JTMS)

Notes on the sheet:
リセット用スイッチ
エンコーダ用

Board: 2 copper layers, 50.0 x 55.0 mm, 42 parts (21 on the bottom side), 33 nets.

File moter_powerup_boardv3/production/MotorUpGradeBoardV3_bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C11, C14",0603,3,4.7uF,
"C10, C13, C2, C3, C6, C7, C8, C9",0603,8,0.1uF,
C12,0603,1,10nF,
C15,CP_Elec_6.3x4.5,1,220uF,
"C4, C5",0603,2,2.2uF,
D1,0805,1,LED_YELLOW,
D2,0805,1,LED_Green,
"D3, D4",D_SMB,2,D_Shockley,
J1,JST_XH_S5B-XH-A-1_1x05_P2.50mm_Horizontal,1,Conn_01x05_Socket,
J2,PinHeader_2x07_P1.27mm_Vertical,1,Conn_ST_STDC14,
"J3, J5",JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal,2,Conn_01x03_Pin,
J4,JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical,1,Conn_01x05_Socket,
J6,JST_XH_S3B-XH-A-1_1x03_P2.50mm_Horizontal,1,Conn_01x03_Pin,
J7,JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal,1,Conn_01x02_Socket,
L1,L_6.3x6.3_H3,1,22uH,
R1,0603,1,120,
R3,0805,1,10k,
"R4, R5",0603,2,1k,
R6,0603,1,10k,
R7,0603,1,5.90k,
SW1,SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm,1,SW_Wuerth_450301014042,
SW2,SW_PUSH_6mm,1,SW_Push,
U2,LQFP-48_7x7mm_P0.5mm,1,STM32H533CETx,
U3,TI_SO-PowerPAD-8_ThermalVias,1,TPS5430DDA,
U4,SOIC8_D_TEX,1,PTCAN3413DR,

## KiCad design LED_board_v1/LED_board_v1.kicad_pcb

Parts:
C1, C13, C14, C15, C16, C19, C21: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9, C10, C12, C20: 4.7μF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C11: 22μF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C17, C18, C37, C38, C41, C42: 4.7uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C39, C43: 10nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C40, C44: 220uF; CP_Elec_6.3x4.5
D1, D3: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2: D_Shockley; D_SOD-323_HandSoldering
D4: D_Shockley; D_SMB
D5, D6: D_Shockley; D_SMA
FB1: 120; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J3: Conn_01x03_Pin; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
J2: Conn_ST_STDC14; PinHeader_2x07_P1.27mm_Vertical
J12: Conn_01x02_Pin; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J13, J14, J15, J16: Conn_01x02_Pin; JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal
L2, L3: 22uH; L_6.3x6.3_H3
R1, R10, R12: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9, R11: 30.9k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: SW_Push; SW_PUSH_6mm
SW2: SW_SPDT; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm
U2: STM32H533CETx; LQFP-48_7x7mm_P0.5mm
U3, U7: TPS5430DDA; TI_SO-PowerPAD-8_ThermalVias
U4: BD33FC0FP; TO-252-2
U8: PTCAN3413DR; SOIC8_D_TEX

Connections:
+3.3V: C1.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C20.2, C21.2, D2.2 (A), FB1.2, J2.3 (VCC), U2.1 (VBAT), U2.24 (VDD), U2.36 (VDD), U2.48 (VDD), U4.3 (VO), U8.3 (VCC), U8.5 (SHDN,VIO); also elsewhere on the board
+5V: C9.1, C40.1, D2.1 (K), L2.2, R9.1, U4.1 (VCC); also elsewhere on the board
+5VLED2: C44.1, L3.2, R11.1; also elsewhere on the board
+24V: C37.1, C38.1, C41.1, C42.1, D4.1 (K), U3.7 (VIN), U7.7 (VIN)
/can_+: J1.3, J3.1, SW2.2 (B), U8.7 (CANH)
/can_-: J1.2, J3.2, R2.2, U8.6 (CANL)
/pc13: J15.2, U2.2 (PC13)
/pc14: J16.2, U2.3 (PC14)
/pc15: J14.2, U2.4 (PC15)
/ph0: J13.2, U2.5 (PH0)
/tapeled_1: U2.10 (PA0); also elsewhere on the board
/tapeled_2: U2.11 (PA1); also elsewhere on the board
/tapeled_3: U2.12 (PA2); also elsewhere on the board
/tapeled_4: U2.13 (PA3); also elsewhere on the board
/tapeled_5: U2.16 (PA6); also elsewhere on the board
/tapeled_6: U2.17 (PA7); also elsewhere on the board
/tapeled_7: U2.18 (PB0); also elsewhere on the board
/tapeled_8: U2.19 (PB1); also elsewhere on the board
GND: C1.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.1, C21.1, C37.2, C38.2, C40.2, C41.2, C42.2, C44.2, D5.2 (A), D6.2 (A), J1.1, J2.5 (GND), J2.7 (GND), J2.11 (GNDDetect), J3.3, J12.1, J13.1, J14.1, J15.1, J16.1, R1.2, R3.2, R4.2, R10.2, R12.2, SW1.1, U2.8 (VSSA), U2.23 (VSS), U2.35 (VSS), U2.47 (VSS), U3.6 (GND), U3.9 (GNDPAD), U4.2 (GND), U7.6 (GND), U7.9 (GNDPAD), U8.2 (GND), U8.8 (STB); also elsewhere on the board
unnamed: C17.1, U2.22 (VCAP)
unnamed: C18.1, U2.46 (VCAP)
unnamed: D1.2 (A), U2.25 (PB12)
unnamed: D1.1 (K), R3.1
unnamed: D3.2 (A), U2.26 (PB13)
unnamed: D3.1 (K), R4.1
unnamed: D4.2 (A), J12.2
unnamed: C39.2, D5.1 (K), L2.1, U3.8 (PH)
unnamed: C43.2, D6.1 (K), L3.1, U7.8 (PH)
unnamed: R2.1, SW2.1 (A)
unnamed: R1.1, U2.44 (BOOT0)
unnamed: FB1.1, U2.9 (VDDA)
unnamed: C39.1, U3.1 (BOOT)
unnamed: R9.2, R10.1, U3.4 (VSENSE)
unnamed: C43.1, U7.1 (BOOT)
unnamed: R11.2, R12.1, U7.4 (VSENSE)
canrx: U2.32 (PA11), U8.4 (RXD)
cantx: U2.33 (PA12), U8.1 (TXD)
jtdi: J2.10 (JTDI/NC), U2.38 (PA15(JTDI))
nrst: C19.1, J2.12 (~RST), SW1.2, U2.7 (NRST)
strx: J2.13 (VCP_RX), U2.43 (PB7)
sttx: J2.14 (VCP_TX), U2.42 (PB6)
swclk: J2.6 (JCLK/SWCLK), U2.37 (PA14(JTCK)
swdio: J2.4 (JTMS/SWDIO), U2.34 (PA13(JTMS)

Notes on the sheet:
3.3v変圧+逆流防止回路
High Low GND

Parts:
C2: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J4, J6: Conn_01x03_Pin; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J5, J7: Conn_01x03_Pin; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
U5: 74AHCT125; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
+5V: C2.1, J4.2, J5.2, J6.2, J7.2, U5.14 (VCC); also elsewhere on the board
/tapeled_1: U5.9; also elsewhere on the board
/tapeled_2: U5.12; also elsewhere on the board
/tapeled_3: U5.5; also elsewhere on the board
/tapeled_4: U5.2; also elsewhere on the board
GND: C2.2, J4.1, J5.1, J6.1, J7.1, U5.1, U5.4, U5.7 (GND), U5.10, U5.13; also elsewhere on the board
unnamed: J4.3, U5.3
unnamed: J5.3, U5.6
unnamed: J6.3, U5.8
unnamed: J7.3, U5.11

Parts of its further copies:
C3: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J8, J10: Conn_01x03_Pin; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J9, J11: Conn_01x03_Pin; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
U6: 74AHCT125; SOIC-14_3.9x8.7mm_P1.27mm

Connections of its further copies:
+5VLED2: C3.1, J8.2, J9.2, J10.2, J11.2, U6.14 (VCC); also elsewhere on the board
/tapeled_5: U6.9; also elsewhere on the board
/tapeled_6: U6.12; also elsewhere on the board
/tapeled_7: U6.5; also elsewhere on the board
/tapeled_8: U6.2; also elsewhere on the board
GND: C3.2, J8.1, J9.1, J10.1, J11.1, U6.1, U6.4, U6.7 (GND), U6.10, U6.13; also elsewhere on the board
unnamed: J8.3, U6.3
unnamed: J9.3, U6.6
unnamed: J10.3, U6.8
unnamed: J11.3, U6.11

Board: 2 copper layers, 80.0 x 65.0 mm, 71 parts (38 on the bottom side), 51 nets.

Other parts of the board:
C1#2: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder

Their connections:
+3.3V: C1#2.2; also elsewhere on the board
GND: C1#2.1; also elsewhere on the board

File LED_board_v1/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1_2, C1, C13, C14, C15, C16, C19, C2, C21, C3",0603,10,0.1uF,
"C10, C12, C20, C9",0805,4,4.7μF,
C11,0805,1,22μF,
"C17, C18, C37, C38, C41, C42",0603,6,4.7uF,
"C39, C43",0603,2,10nF,
"C40, C44",CP_Elec_6.3x4.5,2,220uF,
"D1, D3",0805,2,LED,
D2,D_SOD-323_HandSoldering,1,D_Shockley,
D4,D_SMB,1,D_Shockley,
"D5, D6",D_SMA,2,D_Shockley,
"FB1, R2",0603,2,120,
"J1, J11, J3, J5, J7, J9",JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal,6,Conn_01x03_Pin,
"J10, J4, J6, J8",JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical,4,Conn_01x03_Pin,
J12,AMASS_XT30PW-M_1x02_P2.50mm_Horizontal,1,Conn_01x02_Pin,
"J13, J14, J15, J16",JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal,4,Conn_01x02_Pin,
J2,PinHeader_2x07_P1.27mm_Vertical,1,Conn_ST_STDC14,
"L2, L3",L_6.3x6.3_H3,2,22uH,
"R1, R10, R12",0603,3,10k,
"R11, R9",0603,2,30.9k,
"R3, R4",0603,2,1k,
SW1,SW_PUSH_6mm,1,SW_Push,
SW2,SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm,1,SW_SPDT,
U2,LQFP-48_7x7mm_P0.5mm,1,STM32H533CETx,
"U3, U7",TI_SO-PowerPAD-8_ThermalVias,2,TPS5430DDA,
U4,TO-252-2,1,BD33FC0FP,
"U5, U6",SOIC-14_3.9x8.7mm_P1.27mm,2,74AHCT125,
U8,SOIC8_D_TEX,1,PTCAN3413DR,

## KiCad design md_test_v1/moterdriver_test_v1.kicad_pcb

Parts:
C1, C2: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3: 10uf; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4, C6, C7: 0.1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5: 1uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8: 250uF; CP_Radial_D12.5mm_P5.00mm
C9, C10: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D2: SMBJ26A; D_SMB
D3: D_Zener; D_SOD-123
J1: Conn_01x02_Socket; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J3: Conn_01x02_Socket; AMASS_XT30PW-F_1x02_P2.50mm_Horizontal
J4: Conn_02x06_Odd_Even; PinHeader_2x06_P2.54mm_Vertical
Q1, Q2, Q3, Q4, Q5, Q6: Q_NMOS_GDS; TO-252-2
R2: 18k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 200k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R6, R7, R8, R9, R10, R11, R13: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 2m; R_1225_3264Metric_Pad1.47x6.45mm_HandSolder
R12: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14, R15: 10; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: DRV8701PRGER; RGE0024F

Connections:
+24V: C3.1, C4.1, C5.1, C8.1, C9.1, C10.1, D2.1 (A1), J1.2, Q2.2 (D), Q4.2 (D), R13.1, U1.1 (VM)
/SO_out: R12.1, U1.11 (SO)
/Vref: C7.1, R2.2, R4.2, U1.6 (VREF)
/faultN_out: J4.9, R6.1, U1.9 (FAULT_N)
/pwm_in1: J4.1, U1.15 (PH_IN1)
/pwm_in2: J4.3, U1.14 (EN_IN2)
/sleepN_in: J4.5, U1.13 (SLEEP_N)
/sns_out: J4.7, R7.1, U1.10 (SNSOUT)
GND: J1.1, Q5.2 (D), Q6.2 (D)
GND1: C1.2, C2.2, C3.2, C4.2, C7.2, C8.2, C9.2, C10.2, D2.2 (A2), D3.2 (A), J4.2, J4.4, J4.6, J4.8, J4.10, J4.12, Q5.3 (S), Q6.3 (S), R3.1, R4.1, R5.2, U1.5 (GND), U1.16 (GND), U1.20 (SN), U1.25 (PAD), U1.V
unnamed: D3.1 (K), R13.2, R14.1, R15.1
unnamed: J3.1, Q1.2 (D), Q2.3 (S), R10.1, U1.23 (SH2)
unnamed: J3.2, Q3.2 (D), Q4.3 (S), R8.1, U1.18 (SH1)
unnamed: J4.11, R12.2
unnamed: Q1.1 (G), R11.2, U1.22 (GL2)
unnamed: Q1.3 (S), Q3.3 (S), R5.1, R9.2, R11.1, U1.21 (SP)
unnamed: Q2.1 (G), R10.2, U1.24 (GH2)
unnamed: Q3.1 (G), R9.1, U1.19 (GL1)
unnamed: Q4.1 (G), R8.2, U1.17 (GH1)
unnamed: Q5.1 (G), R15.2
unnamed: Q6.1 (G), R14.2
unnamed: C1.1, R2.1, U1.7 (AVDD)
unnamed: C6.1, U1.3 (CPH)
unnamed: C6.2, U1.4 (CPL)
unnamed: C2.1, R6.2, R7.2, U1.8 (DVDD)
unnamed: R3.2, U1.12 (IDRIVE)
unnamed: C5.2, U1.2 (VCP)

Notes on the sheet:
XT60
定格50V以上厳守
gate
source
drain
